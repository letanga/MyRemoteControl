# Keil uVision project remote.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: remote +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\CORE;..\FWLIB\inc;..\HARDWARE\ADC_DMA;..\HARDWARE\EEPROM;..\HARDWARE\NRF24L01;..\HARDWARE\Remote;..\HARDWARE\SPI;..\SYSTEM\DELAY;..\SYSTEM\USART;..\USER;..\HARDWARE\Systick;..\HARDWARE\BEEP;..\HARDWARE\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/ADC_DMA/: ADC_DMA_Config.c
    ../HARDWARE/EEPROM/: EEPROM.c
    ../HARDWARE/NRF24L01/: nrf24l01.c
    ../HARDWARE/Remote/: remote.c
    ../HARDWARE/SPI/: Spi.c
    ../HARDWARE/Systick/: systick.c
    ../HARDWARE/BEEP/: Beep.c
    ../HARDWARE/OLED/: oled.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group SYSTEM
    ../SYSTEM/DELAY/: delay.c
    ../SYSTEM/USART/: USART.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
